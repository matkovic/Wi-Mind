<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_echotimer_fmcw_edited</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>5.2e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_fac</value></param>
<param><key>value</key><value>2**3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay_samp</value></param>
<param><key>value</key><value>79</value></param>
<param><key>label</key><value>Number delay samples</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res_up</value></param>
<param><key>value</key><value>samp_rate/samp_up</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_output_buffer</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>int((samp_up)*2)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>protect_samp</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>range_res</value></param>
<param><key>value</key><value>3e8/2/sweep_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>range_time</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>60</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>40000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_up</value></param>
<param><key>value</key><value>2**15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sweep_freq</value></param>
<param><key>value</key><value>samp_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>-150</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wait_to_start</value></param>
<param><key>value</key><value>0.02</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/tmatko/Desktop/grstuff/acquired-signals/phase13.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/tmatko/Desktop/grstuff/acquired-signals/time13.dat</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>1.0/decim_fac</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt
import matplotlib.pyplot as plt

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Embedded Python Block',   # will show up in GRC
            in_sig=None,
            out_sig=[np.float32, np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        #self.example_param = example_param
	self.message_port_register_in(pmt.intern('msg_in'))
	self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

	self.phase = 0	
	self.time = 0
	#self.power = 0
	#plt.ion()



    def work(self, input_items, output_items):
        """example: multiply with constant"""
        #output_items[0][:] = input_items[0] * self.example_param
	#print input_items[0]
	output_items[0][:] = self.phase
	output_items[1][:] = self.time
	#output_items[2][:] = self.power
        return 1  # len(output_items[0])

    def handle_msg(self, msg):
	d_size_msg = pmt.length(msg);  # rx_time, frequency, power, phase
	
	time_tuple = pmt.nth(1, pmt.nth(0, msg))
	time_s = pmt.to_uint64(pmt.tuple_ref(time_tuple,0))	
	time_ms = pmt.to_double(pmt.tuple_ref(time_tuple,1))	
	timestamp = time_s + time_ms

	phase_val_vec = pmt.nth(1, pmt.nth(d_size_msg-1, msg))
	phase_val = pmt.f32vector_elements(phase_val_vec)[0]
	
	#plt.scatter(timestamp, phase_val)
	#plt.pause(0.05)

	#power_val_vec = pmt.nth(1, pmt.nth(d_size_msg-2, msg))
	#power_val = pmt.f32vector_elements(power_val_vec)[0]
	
	self.phase = phase_val
	self.time = timestamp
	#self.power = power_val
	#print phase_val_vec
</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>300</value></param>
<param><key>srate</key><value>samp_rate/decim_fac</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>power</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>samp_protect</key><value>int(protect_samp)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
</block>
<block>
<key>radar_my_find_max_peak_c</key>
<param><key>id</key><value>radar_my_find_max_peak_c_0</value></param>
<param><key>bucket</key><value>44</value></param>
<param><key>max_freq</key><value></value></param>
<param><key>samp_protect</key><value>int(protect_samp)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>cut_max_freq</key><value>False</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>"/home/tmatko/Desktop/grstuff/acquired-signals/1.txt"</value></param>
<param><key>store_msg</key><value>False</value></param>
</block>
<block>
<key>radar_signal_generator_fmcw_c</key>
<param><key>id</key><value>radar_signal_generator_fmcw_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>freq_cw</key><value>-sweep_freq/2</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_cw</key><value>0</value></param>
<param><key>samp_down</key><value>0</value></param>
<param><key>samp_up</key><value>samp_up</value></param>
<param><key>freq_sweep</key><value>sweep_freq</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_1</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>samp_up/decim_fac</value></param>
</block>
<block>
<key>radar_usrp_echotimer_cc</key>
<param><key>id</key><value>radar_usrp_echotimer_cc_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>num_delay_samps</key><value>int(delay_samp)</value></param>
<param><key>antenna_rx</key><value>'RX2'</value></param>
<param><key>args_rx</key><value></value></param>
<param><key>clock_source_rx</key><value>'internal'</value></param>
<param><key>gain_rx</key><value>rx_gain</value></param>
<param><key>time_source_rx</key><value>'none'</value></param>
<param><key>wait_rx</key><value>wait_to_start</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>antenna_tx</key><value>'TX/RX'</value></param>
<param><key>args_tx</key><value></value></param>
<param><key>gain_tx</key><value>tx_gain</value></param>
<param><key>wait_tx</key><value>wait_to_start</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>decim_fac</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_ts_fft_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>Msg out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0_0</source_block_id><sink_block_id>radar_print_results_0_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_my_find_max_peak_c_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>Msg out</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>radar_my_find_max_peak_c_0</source_block_id><sink_block_id>radar_print_results_0_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>radar_usrp_echotimer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_1</source_block_id><sink_block_id>radar_find_max_peak_c_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_1</source_block_id><sink_block_id>radar_my_find_max_peak_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_usrp_echotimer_cc_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
